# Repository Agilack/eCow-logic (continued)

## KiCad design pico-ice40-1k/hw-shield-buzzer/shield.kicad_pcb

Board: 2 copper layers, 53.3 x 53.8 mm, 30 parts (0 on the bottom side), 31 nets.

Parts:
C1, C10, C12: 0.1u; C_0805
C2, C9: 10u; C_0805
C3: 0.1uF; C_0805
C4: 1uF; C_0805
C5, C6, C7, C8, C18: 1u; C_0805
C11, C13: 47n; C_0805
C16, C17: 47u; C_0805
J1: JACK_TRS_6PINS; Jack Cliff FC68131
P1, P2: CONN_12; Pin_Header_Straight_1x12
P3: CONN_01X02; Pin_Header_Straight_1x02
R1, R3: 110k; R_0603
R2: 10k; R_0603
R4, R5: 4.7k; R_0603
SP1: SPEAKER; LOUDSPEAKER-ABS-216-RC
SW2: SW_PUSH; SW_PUSH_SMALL
U1: TLV320DAC3203; QFN-24-1EP_4x4mm_Pitch0.5mm
U2: LD39015M18R; SOT-23-5
U3: TPA2005D1; MSOP-8-1EP_3x3mm_Pitch0.65mm

Connections:
+1V8: C8.1, U1.22, U2.5
+3V3: C1.1, C7.1, C9.1, C10.1, P1.1, R2.1, R4.1, R5.1, U1.11, U1.24, U2.1, U2.3
+5V: C2.1, C12.1, P3.2, U3.6
/RESET: C5.1, P1.11, R2.2, SW2.1, U1.20
/SD: C18.1, P2.3, U3.1
BCLK: P1.9, U1.2
DIN: P1.7, U1.4
DOUT: P1.6, U1.5
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C18.2, J1.1, P1.12, P3.1, SW2.2, U1.14, U1.21, U1.23, U1.25, U2.2, U3.7, U3.9
Haut-Parleur-L: C11.1, C16.2, U1.12
Haut-Parleur-R: C13.1, C17.2, U1.10
MCBIAS: P2.7, U1.18
MCLK: P1.10, U1.1
MISO: P1.2, U1.9
unnamed: C3.2, C4.2, U1.13
unnamed: C6.1, U1.17
unnamed: C11.2, R1.2
unnamed: C13.2, R3.2
unnamed: C16.1, J1.2
unnamed: C17.1, J1.3
unnamed: P2.4, U1.16
unnamed: P2.5, U1.15
unnamed: R1.1, U3.3
unnamed: R3.1, U3.4
unnamed: SP1.1, U3.5
unnamed: SP1.2, U3.8
SCL: P1.4, R4.2, U1.7
SCLK: P1.5, U1.6
SDA: P1.3, R5.2, U1.8
SPI_Select: P2.6, U1.19
WCLK: P1.8, U1.3

## Commit log

2015-11-16 = ADD: pcb project for pico-1k
2015-11-17 = ADD: Netlist, module library and reference-footprint references
2015-11-18 = ADD: PCB routing (not complete)
2015-11-19 = UPD: board routing - ready for verification
2015-11-20 = ADD: Export production files
2015-11-23 = ADD: Probe Unit-test for UART2, based on w7500 std library
2015-11-24 = ADD: Probe Unit test for OLED display
2015-11-25 = ADD: Probe Unit Test for PHY management interface (MIIM)
2015-11-26 = ADD: Probe Unit Test for PLD load using SPI
2015-11-27 = ADD: Probe unit-test for network interface (using UDP socket)
2015-11-30 = ADD: Probe unit-test for external SPI flash memory
2015-12-01 = ADD: Pictures of the PCB
2015-12-02 = ADD: Electrical tests for power supply
2015-12-03 = UPD: Fix OLED reset bug
2015-12-04 = UPD: OLED test show a static image instead or binary pattern
2015-12-07 = ADD: Add the small tool used to convert images to OLED unit-test
2015-12-08 = UPD: Improve PLD unit-test : load a real design into the PLD
2015-12-09 = UPD: Improve PLD-ut : embedded bitstream as binary (no more .h conversion)
2015-12-10 = ADD: Unit test for dual bootloader + firmware application
2015-12-11 = Fix: An electrical error has been detected (Flash memory) Add a bug repport.
2015-12-14 = ADD: Create a bootlarder app - include basic dhcp setup
2015-12-15 = UPD: bootloader, add basic tftp request
2015-12-16 = UPD: bootloader, include ack for full transfer process
2015-12-17 = UPD: downloaded file is now written to flash memory using IAP
2015-12-18 = UPD: Jump to firmware in upper memory in "normal" mode
2015-12-19 = ADD: Small unit-test to understand how IAP works
2015-12-20 = UPD: add comments to asm reversed file, and a linker script to re-compile it
2015-12-21 = ADD: create a skeleton of the main probe firmware
2015-12-22 = UPD: allow firmware to use bootloader functions (basic API)
2015-12-24 = UPD: improve tftp and api layer - tftp client: file name moved into session - firmware: init all api functions on startup
2015-12-25 = UPD: add PLD load function. Bitstream is loaded from TFTP, and FPGA start \o/
2015-12-29 = UPD: Add HTTP server -very experimental- This changes, momentarily break other network functions (!)
2015-12-30 = UPD: add call to DHCP client on statup (mainly to test bootloader API)
2015-12-31 = UPD: Improve TFTP client - remove big buffers copy, use direct TOE memory
2016-01-01 = Improve DHCP client - Remove big buffers copy, use TOE memory
2016-01-02 = UPD: decode more functions, mainly for memory write
2016-01-04 = Insert external flash functions to bootloader
2016-01-05 = Add: In loader mode, search download and write flash memory image (if available)
2016-01-06 = UPD: Fix OLED end of transfer (flush fifo to avoid side-effect on flash) ; fix typo into flash header ; remove some unued interrupt handlers
2016-01-07 = ADD: Small (and custom) filesystem layer for spi flash storage
2016-01-08 = UPD: Move TFTP client port number to session (allow to change it)
2016-01-11 = ADD: Allow to load pages from external flash using /p/<name> URI
2016-01-12 = UPD: enable support of multiple content-types into http results
2016-01-13 = ADD: Start a new board revision (r0.2) to fix all known bugs
2016-01-14 = UPD: Improve schema, change IOs/extension connector (HE10 pins), fix display
2016-01-15 = UPD: Add board netlist and routing
2016-01-16 = ADD: production files for board r0.2
2016-01-18 = UPD: Call pld_*() when data are posted on /pld -> load PLD using http
2016-01-19 = ADD: First HDL example - Drive LEDs to blink them as "K2000"
2016-01-20 = ADD: HDL demo/example of VGA sync signals generation
2016-01-21 = UPD: Insert a new CGI to access SPI port from HTTP
2016-01-22 = ADD: Insert a new HDL example for SPI communication
2016-01-23 = UPD: Add a small form to main web page that allow sending SPI data more easily
2016-01-25 = ADD: Temporary webpage /info that send JSON informations
2016-01-26 = UPD: Improve SPI example, send button status in response to data transfer
2016-01-27 = ADD: Picture of the PCB (without any component)
2016-01-28 = UPD: Move hardware r0.1 documents to right directory
2016-01-28 = BUG: Insert a but repport about W7500 test pin (not fatal)
2016-01-29 = UPD: Modify bootloader according to new pins usage of W7500 (U900)
2016-02-01 = UPD: Increase SPI0 speed (reduce prescaler)
2016-02-02 = UPD: Fix error into flash update functions (wait Write-In-Progress)
2016-02-03 = UPD: Allow to send HTTP response in more than one packet/transfer
2016-02-04 = UPD: Use the new multi-packet feature of HTTP to send large contents from flash
2016-02-05 = ADD: Allow to load CSS and JPG files from external flash
2016-02-08 = ADD: Datas (and mainly webpages) to load into external flash
2016-02-09 = ADD: tool to create flash image from files
2016-02-09 = UPD: Remove the internal index webpage, and replace with a redirect to /p/
2016-02-10 = UPD: Improve web page (add toolbar and split design by function)
2016-02-11 = UPD: Clean main - remove old/unused TFTP support ; allow b2ds for value > 10000 (needed for HTTP Content-Length)
2016-02-12 = ADD: Start to write a new http stack : to improve memory use ; to fix some issues with multiple connections
2016-02-13 = UPD: Clean some unused var and old function ; Fix formating error into string sent to display
2016-02-15 = UPD: New HTTP - Move server config to struct ; add function to decode header
2016-02-16 = ADD: New HTTP layer, add squeleton of content/URI support
2016-02-16 = UPD: Rename oled_line() to oled_pos() and add a second parameter to specify X position
2016-02-17 = UPD: Bootloader forward some interrupts to main firmware (systick, ssp1, uart1)
2016-02-17 = ADD: New HTTP, call cgi handler and send results (only 1 packet for the moment)
2016-02-18 = UPD: New HTTP layer, allow to send HTTP response into multiple packets
2016-02-18 = UPD: New HTTP, allow to receive a content from multiple packets
2016-02-19 = UPD: Remove The 'old' HTTP stack
2016-02-19 = FIX: small
2016-02-20 = UPD: Move function used in "loader" mode to a dedicated file. Add more functions to libc (and rename delay to msleep).
2016-02-21 = UPD: Move /spi cgi handler to a dedicated file
2016-02-21 = UPD: Improve SPI cgi, allow to exchange multiple bytes. Use js on client side to process spi form
2016-02-22 = ADD: Move the new HTTP support to bootloader as shared resource
2016-02-23 = UPD: Improve DHCP support (allow retry) and move TFTP state machine to dedicated function
2016-02-24 = ADD: Create a basic HTTP script to launch HTTP server in bootloader mode (only show static content for the moment)
2016-02-25 = UPD: The main CGI now write received data content to internal memory
2016-02-25 = UPD: Remove the local copy of HTTP server and use API instead
2016-02-26 = ADD: Insert a new cgi to load external flash memory ; Fix bug with TOE fifo pointer
2016-02-27 = ADD: Insert a "config" layer to save persistent data to DATA1 block
2016-02-29 remove found var and move specific get code to the while loop
2016-03-02 = DBG: Clean some debug code and messages
2016-03-03 = UPD: Fix bug into HTTP rx : socket buffer could not be written ( ! ! )
2016-03-04 = UPD: Small cleanup of unsed/old/debug code and messages
2016-03-04 = UPD: Allow to specify custom content for "404" into a server ; remove default/static HTML
2016-03-05 = UPD: Move strings displayed on OLED to external header (i18n)
2016-03-07 = UPD: Move HTML content used by CGI to header files ; Add message on upload success
2016-03-07 = UPD: Improve homepage, add color and draw panels, squeleton of (future) "online" update
2016-03-08 = ADD: Create a new small cgi "infos" that return some board informations (version, uid, ...)
2016-03-09 = UPD: Update http according to recent bootloader changes (403 / 404 / volatile buffers, ...)
2016-03-09 = UPD: Improve webpage ; fix wait/timing error into cgi flash
2016-03-10 = UPD: Increase the maximum value of decimal-to-string conversion function
2016-03-11 = UPD: Split log messages into two levels Info and Debug
2016-03-12 = UPD: add keep-alive header (timeout, max request) and ad small wait-loop when the socket is closed after an error
2016-03-14 = ADD: re-enable and update the /infos cgi used by new online api/ide
2016-03-15 = FIX: bug into "page" cgi : write into RX buffer is not allowed (!)
2016-03-16 = UPD: Improve embedded html/css + rename layer to ptab to avoir collision with cowlab-ide
2016-03-16 = UPD: small cleanup of old include files
2016-03-17 = ADD: Allow to use keep-alive or not (defined by a server flag) - ToDo: timeout support not complete
2016-03-17 = UPD: add http server keep-alive flag according to last bootloader update
2016-03-18 = FIX: retry DHCP request if no lease received
2016-05-13 Add schema and kicad project
2016-05-13 Add librairies and upd sch
2016-05-17 Modif schem +lib
2016-05-17 ADD PCB
2016-05-18 added gitignore
2016-05-18 new schema and PCB with lib for jack connector
2016-05-19 Modif sch and pcb
2016-05-19 update sch and pcb; add a speaker
2016-05-20 sch : Pull_up resistor added; Modif pcb; New files in .pretty
2016-05-20 Small changes on the pcb
2016-05-24 Changed spi CS behavior
2016-05-24 change SPI CS behavior
2016-05-26 Modif 2 pins header position
2016-06-03 = FIX: init all vars, fix signed/unsigned op, fix inline reg_*, and some gcc warnings on unused variables
2016-06-03 = FIX: inline function declaration
    With gcc 6.1.1, the compilation failed due to undefined function `reg_rd`,
    `reg_wr` and `reg_set`.
    See <http://www.greenend.org.uk/rjk/tech/inline.html>.
2016-06-05 = ADD: use enumeration for tftp states
2016-06-05 hdl solutions in progress and more recent PCB design
2016-06-06 Ignore binary files
2016-06-06 Remove temporary files
2016-06-06 Remove object files
2016-06-06 Ignore temporary files
2016-06-10 = UPD: according to issue/2 move board files
2016-06-10 = UPD: according to issue/2 move PCB files (board v1 available into a branch)
2016-06-11 = FIX: Update clock config on startup (no more external oscillator & PLL) ; fix missing enum tftp states
2016-06-11 = Fix: Board ident and key for loader is at 0x3FE00 (system config page)
2016-06-11 = UPD: update files organisation (see to issue/2)
2016-06-11 = ADD: technical block-diagram and some pics
2016-06-16 Modification in the hdl sources and I2C Beep working
2016-06-21 Improve logo outline
2016-06-23 Add required attribut for file inputs
2016-06-30 = UPD: Update hardware for rev 0.2.1 board (mainly bugfix)
2016-06-30 = UPD: Update production files for rev 0.2.1
2016-07-02 = UPD: set values and manufacturer ref for components
2016-07-02 = UPD: export new components values to netlist
2016-07-02 = UPD: update silkscreen for components values
2016-07-08 ADD and UP hdl file, ram added
2016-07-08 new configuration files and notes on how to use the shield
2016-07-08 ADD quick configuration
2016-07-12 Check file name format
2016-07-12 Use sprite for images
2016-12-30 = UPD: Improve DHCP client - remove all static variables and move necessary informations into a newly created "session" structure. This update will allow calling DHCP functions outside bootloader
