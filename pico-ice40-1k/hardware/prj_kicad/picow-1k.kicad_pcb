# Repository Agilack/eCow-logic

File README.md:

# eCow-logic

 * pico-ice40-1k : pico-ITX board with Lattice ICE40 FPGA (HX-1k)

## KiCad design pico-ice40-1k/hardware/prj_kicad/picow-1k.kicad_pcb

Schematic: picow-1k.sch

Parts:
R1: 10k
U1: ICE40HX1K-TQ144
X1: 25MHz
dP1: CONN_RJ45-DUMMY

Connections:
+1.2V: U1.27, U1.36 (PLL), U1.51, U1.92, U1.111; also elsewhere on the board
+2.5V: U1.108 (2V5); also elsewhere on the board
+3.3V: U1.6, U1.30, U1.46, U1.57, U1.72 (VCC_SPI), U1.89, U1.100, U1.123, U1.133, X1.4; also elsewhere on the board
BUT1: U1.62 (IO41); also elsewhere on the board
BUT2: U1.63 (CBS0_IO42); also elsewhere on the board
BUT3: U1.64 (CBS1_IO43); also elsewhere on the board
BUT4: U1.61 (IO40); also elsewhere on the board
CLK_EN: U1.129 (GB0_IO85), X1.1 (En)
CLOCK: U1.128 (GB1_IO84), X1.3 (Out)
EXT_01A: U1.73 (IO48); also elsewhere on the board
EXT_01B: U1.74 (IO49); also elsewhere on the board
EXT_02A: U1.75 (IO50); also elsewhere on the board
EXT_02B: U1.76 (IO51); also elsewhere on the board
EXT_03A: U1.78 (IO52); also elsewhere on the board
EXT_03B: U1.79 (IO53); also elsewhere on the board
EXT_04A: U1.80 (IO54); also elsewhere on the board
EXT_04B: U1.81 (IO55); also elsewhere on the board
EXT_05A: U1.87 (IO56); also elsewhere on the board
EXT_05B: U1.88 (IO57); also elsewhere on the board
EXT_06A: U1.90 (IO58); also elsewhere on the board
EXT_06B: U1.91 (IO59); also elsewhere on the board
EXT_07A: U1.93 (IO60_GB3); also elsewhere on the board
EXT_07B: U1.94 (IO61_GB2); also elsewhere on the board
EXT_08A: U1.95 (IO62); also elsewhere on the board
EXT_08B: U1.96 (IO63); also elsewhere on the board
EXT_09A: U1.97 (IO64); also elsewhere on the board
EXT_09B: U1.98 (IO65); also elsewhere on the board
EXT_10A: U1.101 (IO67); also elsewhere on the board
EXT_10B: U1.102 (IO68); also elsewhere on the board
EXT_11A: U1.104 (IO69); also elsewhere on the board
EXT_11B: U1.105 (IO70); also elsewhere on the board
EXT_12A: U1.106 (IO71); also elsewhere on the board
EXT_12B: U1.107 (IO72); also elsewhere on the board
GND: R1.1, U1.5, U1.13, U1.14, U1.35 (PLL), U1.59, U1.69, U1.86, U1.103, U1.132, U1.140, X1.2; also elsewhere on the board
LCD_CLK: U1.41 (IO27); also elsewhere on the board
LCD_CS: U1.43 (IO29); also elsewhere on the board
LCD_DC: U1.42 (IO28); also elsewhere on the board
LCD_DI: U1.39 (IO26); also elsewhere on the board
LED0: U1.60 (IO39); also elsewhere on the board
LED1: U1.58 (IO38); also elsewhere on the board
LED2: U1.56 (IO37); also elsewhere on the board
LED3: U1.52 (IO34); also elsewhere on the board
LED4: U1.48 (IO33); also elsewhere on the board
LED5: U1.47 (IO32); also elsewhere on the board
LED6: U1.45 (IO31); also elsewhere on the board
LED7: U1.44 (IO30); also elsewhere on the board
unnamed: R1.2, U1.77 (TRST)
NET_RX: U1.38 (IO25); also elsewhere on the board
NET_TX: U1.37 (IO24); also elsewhere on the board
PLD_CS: U1.71 (SS); also elsewhere on the board
PLD_DONE: U1.65 (DONE); also elsewhere on the board
PLD_IT: U1.49 (IO35_GB5); also elsewhere on the board
PLD_MISO: U1.67 (SDO); also elsewhere on the board
PLD_MOSI: U1.68 (SDI); also elsewhere on the board
PLD_RST: U1.66 (RST); also elsewhere on the board
PLD_SCK: U1.70 (SCK); also elsewhere on the board
RAM_A0: U1.9 (IO4A); also elsewhere on the board
RAM_A1: U1.11 (IO5A); also elsewhere on the board
RAM_A2: U1.138 (IO91); also elsewhere on the board
RAM_A3: U1.19 (IO6A); also elsewhere on the board
RAM_A4: U1.20 (GB7_IO6B); also elsewhere on the board
RAM_A5: U1.22 (IO7B); also elsewhere on the board
RAM_A6: U1.24 (IO8B); also elsewhere on the board
RAM_A7: U1.26 (IO9B); also elsewhere on the board
RAM_A8: U1.21 (GB6_IO7A); also elsewhere on the board
RAM_A9: U1.141 (IO93); also elsewhere on the board
RAM_A10: U1.142 (IO94); also elsewhere on the board
RAM_A11: U1.143 (IO95); also elsewhere on the board
RAM_A12: U1.29 (IO10B); also elsewhere on the board
RAM_A13: U1.23 (IO8A); also elsewhere on the board
RAM_A14: U1.31 (IO11A); also elsewhere on the board
RAM_A15: U1.32 (IO11B); also elsewhere on the board
RAM_A16: U1.33 (IO12A); also elsewhere on the board
RAM_A17: U1.28 (IO10A); also elsewhere on the board
RAM_A18: U1.34 (IO12B); also elsewhere on the board
RAM_CE: U1.144 (IO96); also elsewhere on the board
RAM_DQ0: U1.7 (IO3A); also elsewhere on the board
RAM_DQ1: U1.4 (IO2B); also elsewhere on the board
RAM_DQ2: U1.2 (IO1B); also elsewhere on the board
RAM_DQ3: U1.1 (IO1A); also elsewhere on the board
RAM_DQ4: U1.3 (IO2A); also elsewhere on the board
RAM_DQ5: U1.8 (IO3B); also elsewhere on the board
RAM_DQ6: U1.10 (IO4B); also elsewhere on the board
RAM_DQ7: U1.12 (IO5B); also elsewhere on the board
RAM_OE: U1.139 (IO92); also elsewhere on the board
RAM_WE: U1.25 (IO9A); also elsewhere on the board
VGA_B0: U1.134 (IO87); also elsewhere on the board
VGA_B1: U1.119 (IO80); also elsewhere on the board
VGA_G0: U1.135 (IO88); also elsewhere on the board
VGA_G1: U1.120 (IO81); also elsewhere on the board
VGA_HS: U1.118 (IO79); also elsewhere on the board
VGA_R0: U1.136 (IO89); also elsewhere on the board
VGA_R1: U1.121 (IO82); also elsewhere on the board
VGA_VS: U1.117 (IO78); also elsewhere on the board

Parts:
C901, C902, C916, C917: 100nF
C903, C911, C914, C915: 1uF
C904: 4,7uF
C910, C920: 2,2uF
C913, C918: 10nF
C921: 10uF
L901: FB120
P1: CONN_RJ45-L
Q901: BC846
R901, R902, R903, R904: 75
R905: 6,49k
R906, R907, R911, R912: 10k
R908: R
R909, R910: 330
SW900, SW901: SW_PUSH
T900: TRANSFORMER_1:1
TP901, TP902, TP903, TP905, TP906, TP907: CONN_1
TP904: CONN_4
U900: W7500
U901: KSZ8091MNX
U902: M25P16-VME
U903: NCP302
X900: 25MHz
X901: 8MHz

Connections:
+3.3V: C910.1, C916.1, C917.1, C918.1, C920.1, C921.1, L901.1, R906.1, R907.1, R908.1, R909.2, R910.1, TP904.4, U900.10, U900.61, U901.17 (VDDIO), U902.3 (IO2_WP), U902.7 (IO3_HOLD), U902.8 (VCC), U903.2 (IN), X900.4, X901.4; also elsewhere on the board
BRK: C914.1, R907.2, SW900.2, U900.30 (PA1)
ETH_CLK25: U901.9 (XI), X900.3 (Out)
ETH_DBG_RX: TP904.3, U900.4 (PC11)
ETH_DBG_TX: TP904.2, U900.3 (PC10)
ETH_LED0: P1.A2, U901.30 (LED0)
ETH_LED1: R911.1, U900.29 (PA0)
ETH_RST: C903.1, R906.2, U901.32 (RST)
GND: C901.2, C902.2, C903.2, C904.2, C910.2, C911.2, C913.2, C914.2, C915.2, C916.2, C917.2, C918.2, C920.2, C921.2, P1.9 (SHIELD), Q901.2 (E), R901.1, R902.2, R903.1, R904.2, R905.2, R912.2, SW900.1, SW901.1, TP904.1, U900.9, U900.32 (TEST), U900.62, U901.1, U901.PAD, U902.4 (GND), U903.3, X900.2, X901.2; also elsewhere on the board
LCD_CS2: U900.41 (PA12); also elsewhere on the board
LCD_DC2: U900.40 (PA11); also elsewhere on the board
LCD_EN: U900.44 (PA15); also elsewhere on the board
LCD_RST: U900.38 (PA10); also elsewhere on the board
LCD_SW: U900.31 (PA2); also elsewhere on the board
MDC_CLK: U900.27 (PB15), U901.12 (MDC)
MDC_IO: U900.26 (PB14), U901.11 (MDIO)
MII_COL: U900.25 (PB5), U901.28 (COL)
MII_CRS: U900.11 (PD0), U901.29 (CRS)
MII_RXC: U900.17 (PB7), U901.19 (RXCLK)
MII_RXD0: U900.13 (PD2), U901.16 (RXD0)
MII_RXD1: U900.14 (PD3), U901.15 (RXD1)
MII_RXD2: U900.15 (PD4), U901.14 (RXD2)
MII_RXD3: U900.16 (PB6), U901.13 (RXD3)
MII_RXDV: U900.12 (PD1), U901.18 (RXDV)
MII_TXC: U900.19 (PB9), U901.22 (TXCLK)
MII_TXD0: U900.20 (PB10), U901.24 (TXD0)
MII_TXD1: U900.21 (PB11), U901.25 (TXD1)
MII_TXD2: U900.22 (PB12), U901.26 (TXD2)
MII_TXD3: U900.23 (PB13), U901.27 (TXD3)
MII_TXEN: U900.24 (PB4), U901.23 (TXEN)
unnamed: TP901.1, U900.49 (PA3/SWDCK)
unnamed: TP902.1, U900.50 (PA4/SWDIO)
unnamed: U900.63 (XTAL_I), X901.3 (Out)
unnamed: T900.8, U901.4 (RX-)
unnamed: C915.1, SW901.2, U903.5 (C)
unnamed: TP905.1, U900.42 (PA13)
unnamed: TP906.1, U900.43 (PA14)
unnamed: R912.1, TP903.1, U900.39 (BOOT)
unnamed: P1.B1, R910.2
unnamed: P1.B2, Q901.3 (C)
unnamed: P1.A1, R909.1
unnamed: Q901.1 (B), R911.2
unnamed: T900.3, U901.6 (TX-)
unnamed: C901.1, T900.2
unnamed: C902.1, T900.7
unnamed: T900.1, U901.7 (TX+)
unnamed: T900.6, U901.5 (RX+)
unnamed: P1.1, T900.16
unnamed: P1.6, T900.9
unnamed: P1.2, T900.14
unnamed: P1.3, T900.11
unnamed: R901.2, T900.10
unnamed: P1.7, P1.8, R904.1
unnamed: R902.1, T900.15
unnamed: P1.4, P1.5, R903.2
unnamed: R905.1, U901.10 (REXT)
unnamed: C904.1, U901.2 (VDD_1V2)
NET_RST: R908.2, TP907.1, U900.28 (RST), U903.1 (RST)
NET_RX: U900.55 (PC2); also elsewhere on the board
NET_TX: U900.56 (PC3); also elsewhere on the board
PLD_CS: U900.45 (PB0); also elsewhere on the board
PLD_DONE: U900.57 (PC4); also elsewhere on the board
PLD_IT: U900.53 (PC0); also elsewhere on the board
PLD_MISO: U900.47 (PB2); also elsewhere on the board
PLD_MOSI: U900.48 (PB3); also elsewhere on the board
PLD_RST: U900.58 (PC5); also elsewhere on the board
PLD_SCK: U900.46 (PB1); also elsewhere on the board
SPI0_CS: U900.33 (PA5), U902.1 (CS)
SPI0_MISO: U900.35 (PA7), U902.2 (IO1_DO)
SPI0_MOSI: U900.36 (PA8), U902.5 (IO0_DI); also elsewhere on the board
SPI0_SCK: U900.34 (PA6), U902.6 (CLK); also elsewhere on the board

Parts:
C101, C102: 10uF
C103, C104: 1uF
C105, C106: 2,2uF
C107: 100nF
C108: C
C109: 22uF
D100, D101, D102, D103, D104, D105, D106, D107: LED
DISP1: ER-OLED0.91-1
L101: 10uH
L102, L103: FB120
P2: CONN_VGA
R100, R101, R103, R110, R111, R113, R120, R121, R123: 120
R102, R112, R122: 60
R130, R131: R
R132: 560k
R140, R141, R142, R143, R144, R145, R146, R147: 1k
U101: AS6C4008
U102: TLV61220
U103: 74AHC157

Connections:
+3.3V: C107.1, C108.1, DISP1.7 (VDD), L103.1, U101.32, U103.16; also elsewhere on the board
GND: C101.2, C102.2, C105.2, C106.2, C107.2, C108.2, C109.2, D100.2 (K), D101.2 (K), D102.2 (K), D103.2 (K), D104.2 (K), D105.2 (K), D106.2 (K), D107.2 (K), DISP1.6, P2.5 (GND), P2.6 (RGND), P2.7 (GGND), P2.8 (BGND), P2.10 (SGND), R100.2, R110.2, R120.2, R131.2, R132.2, U101.16, U102.2, U103.8; also elsewhere on the board
LCD_CLK: U103.10 (CI1); also elsewhere on the board
LCD_CS: U103.6 (BI1); also elsewhere on the board
LCD_CS2: U103.5 (BI0); also elsewhere on the board
LCD_DC: U103.3 (AI1); also elsewhere on the board
LCD_DC2: U103.2 (AI0); also elsewhere on the board
LCD_DI: U103.13 (DI1); also elsewhere on the board
LCD_EN: U103.15 (EN); also elsewhere on the board
LCD_RST: DISP1.9 (RES); also elsewhere on the board
LCD_SW: U103.1 (S); also elsewhere on the board
LED0: R140.1; also elsewhere on the board
LED1: R141.1; also elsewhere on the board
LED2: R142.1; also elsewhere on the board
LED3: R143.1; also elsewhere on the board
LED4: R144.1; also elsewhere on the board
LED5: R145.1; also elsewhere on the board
LED6: R146.1; also elsewhere on the board
LED7: R147.1; also elsewhere on the board
unnamed: DISP1.10 (D/C), U103.4 (AO)
unnamed: DISP1.13 (IREF), R132.1
unnamed: C105.1, DISP1.14 (VCOMH)
unnamed: DISP1.11 (SCLK), U103.9 (CO)
unnamed: DISP1.12 (SDIN), U103.12 (DO)
unnamed: DISP1.8 (CS), U103.7 (BO)
unnamed: L101.2, U102.1 (SW)
unnamed: R130.2, R131.1, U102.4 (FB)
unnamed: C106.1, DISP1.15 (VCC)
unnamed: C101.1, L101.1, L103.2, U102.3 (EN), U102.6 (VBAT)
unnamed: D105.1 (A), R145.2
unnamed: D106.1 (A), R146.2
unnamed: D104.1 (A), R144.2
unnamed: D103.1 (A), R143.2
unnamed: D102.1 (A), R142.2
unnamed: D101.1 (A), R141.2
unnamed: L102.2, P2.9 (5V)
unnamed: D107.1 (A), R147.2
unnamed: D100.1 (A), R140.2
unnamed: R110.1, R111.2, R112.1
unnamed: R120.1, R121.2, R122.1
unnamed: R100.1, R101.2, R102.1
unnamed: C103.1, DISP1.3 (C1P)
unnamed: C104.1, DISP1.1 (C2P)
unnamed: C104.2, DISP1.2 (C2N)
unnamed: C103.2, DISP1.4 (C1N)
RAM_A0: U101.12 (A0); also elsewhere on the board
RAM_A1: U101.11 (A1); also elsewhere on the board
RAM_A2: U101.10 (A2); also elsewhere on the board
RAM_A3: U101.9 (A3); also elsewhere on the board
RAM_A4: U101.8 (A4); also elsewhere on the board
RAM_A5: U101.7 (A5); also elsewhere on the board
RAM_A6: U101.6 (A6); also elsewhere on the board
RAM_A7: U101.5 (A7); also elsewhere on the board
RAM_A8: U101.27 (A8); also elsewhere on the board
RAM_A9: U101.26 (A9); also elsewhere on the board
RAM_A10: U101.23 (A10); also elsewhere on the board
RAM_A11: U101.25 (A11); also elsewhere on the board
RAM_A12: U101.4 (A12); also elsewhere on the board
RAM_A13: U101.28 (A13); also elsewhere on the board
RAM_A14: U101.3 (A14); also elsewhere on the board
RAM_A15: U101.31 (A15); also elsewhere on the board
RAM_A16: U101.2 (A16); also elsewhere on the board
RAM_A17: U101.30 (A17); also elsewhere on the board
RAM_A18: U101.1 (A18); also elsewhere on the board
RAM_CE: U101.22 (CE); also elsewhere on the board
RAM_DQ0: U101.13 (DQ0); also elsewhere on the board
RAM_DQ1: U101.14 (DQ1); also elsewhere on the board
RAM_DQ2: U101.15 (DQ2); also elsewhere on the board
RAM_DQ3: U101.17 (DQ3); also elsewhere on the board
RAM_DQ4: U101.18 (DQ4); also elsewhere on the board
RAM_DQ5: U101.19 (DQ5); also elsewhere on the board
RAM_DQ6: U101.20 (DQ6); also elsewhere on the board
RAM_DQ7: U101.21 (DQ7); also elsewhere on the board
RAM_OE: U101.24 (OE); also elsewhere on the board
RAM_WE: U101.29 (WE); also elsewhere on the board
SPI0_MOSI: U103.14 (DI0); also elsewhere on the board
SPI0_SCK: U103.11 (CI0); also elsewhere on the board
VGA_B0: R121.1; also elsewhere on the board
VGA_B1: R123.1; also elsewhere on the board
VGA_BLU: P2.3 (Blu), R122.2, R123.2
VGA_G0: R111.1; also elsewhere on the board
VGA_G1: R113.1; also elsewhere on the board
VGA_GRN: P2.2 (Grn), R112.2, R113.2
VGA_HS: P2.13 (HS); also elsewhere on the board
VGA_R0: R101.1; also elsewhere on the board
VGA_R1: R103.1; also elsewhere on the board
VGA_RED: P2.1 (Red), R102.2, R103.2
VGA_VS: P2.14 (VS); also elsewhere on the board

Parts:
C201, C202, C211, C227: 10uF
C203, C212: C
C204, C213: CP
C205: 22uF
C214, C215, C216, C217, C218, C221, C224, C225, C226, C228: 100nF
C219: 2,2uF
C220, C222, C223: 1uF
L200, L202: 10uH
P3: CONN_DC-2.0
P200: CONN_FIX
R201, R202, R203, R204, R208: R
R205: 15k
R206: 7,5k
R207: 1k
TP201, TP202, TP203, TP204, TP205, TP206, TP207: CONN_1
U200, U202: TPS560200
U201: LD6815

Connections:
+1.2V: C212.1, C213.1, C214.1, C215.1, C216.1, C219.1, L202.2, R203.1, TP202.1; also elsewhere on the board
+2.5V: C211.1, U201.5 (VOUT); also elsewhere on the board
+3.3V: C203.1, C204.1, C217.1, C218.1, C220.1, C221.1, C222.1, C223.1, C224.1, C225.1, C226.1, C227.1, C228.1, L200.2, R201.1, R207.2, TP201.1, U201.1 (VIN), U201.3 (EN); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, P3.2 (GND), P200.0, R202.2, R204.2, R206.1, R208.1, TP203.1, TP204.1, TP205.1, TP206.1, U200.2, U201.2, U202.2; also elsewhere on the board
unnamed: R207.1, R208.2, U202.1 (EN)
unnamed: R205.1, R206.2, TP207.1, U200.1 (EN)
unnamed: R201.2, R202.1, U200.5 (FB)
unnamed: L200.1, U200.3 (PH)
unnamed: R203.2, R204.1, U202.5 (FB)
unnamed: L202.1, U202.3 (PH)

Parts:
C151, C152, C153, C154: 1uF
P4, P5: CONN_12
P6: CONN_2
R151, R152, R153, R154: 10k
SW1, SW2, SW3, SW4: SW_PUSH
TP151, TP152: CONN_1

Connections:
+3.3V: P4.1, R151.1, R152.1, R153.1, R154.1; also elsewhere on the board
BUT1: C151.1, R151.2, SW1.2; also elsewhere on the board
BUT2: C152.1, R152.2, SW2.2; also elsewhere on the board
BUT3: C153.1, R153.2, SW3.2; also elsewhere on the board
BUT4: C154.1, R154.2, SW4.2; also elsewhere on the board
EXT_01A: P5.1; also elsewhere on the board
EXT_01B: P5.2; also elsewhere on the board
EXT_02A: P5.3; also elsewhere on the board
EXT_02B: P5.4; also elsewhere on the board
EXT_03A: P5.5; also elsewhere on the board
EXT_03B: P5.6; also elsewhere on the board
EXT_04A: P5.7; also elsewhere on the board
EXT_04B: P5.8; also elsewhere on the board
EXT_05A: P5.9; also elsewhere on the board
EXT_05B: P5.10; also elsewhere on the board
EXT_06A: P5.11; also elsewhere on the board
EXT_06B: P5.12; also elsewhere on the board
EXT_07A: TP152.1; also elsewhere on the board
EXT_07B: TP151.1; also elsewhere on the board
EXT_08A: P4.11; also elsewhere on the board
EXT_08B: P4.10; also elsewhere on the board
EXT_09A: P4.9; also elsewhere on the board
EXT_09B: P4.8; also elsewhere on the board
EXT_10A: P4.7; also elsewhere on the board
EXT_10B: P4.6; also elsewhere on the board
EXT_11A: P4.5; also elsewhere on the board
EXT_11B: P4.4; also elsewhere on the board
EXT_12A: P4.3; also elsewhere on the board
EXT_12B: P4.2; also elsewhere on the board
GND: C151.2, C152.2, C153.2, C154.2, P4.12, P6.1, SW1.1, SW2.1, SW3.1, SW4.1; also elsewhere on the board

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
Board: 2 copper layers, 100.0 x 72.0 mm, 164 parts (8 on the bottom side), 192 nets.

Other parts of the board:
FIX: VAL**; FIX
FIX#2: VAL**; FIX
OLED Display: VAL**; DISP_OLED-128x32-0.91-1-rev
agilack_600: VAL**; agilack_600
cow_logo: VAL**; cow_logo
ohw_logo: VAL**; ohw-logo

Notices in the files:
pico-ice40-1k/hardware/prj_kicad/picow-1k.kicad_pcb:
Agilack 2016 CC-by-SA
